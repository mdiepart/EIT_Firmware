# IAR project ImpedanceMeasurement_4Wire.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM350 AnalogDevices ADuCM350
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_SYSTEM_CLOCK_TRANSITION; ADI_DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\src; ..\inc; ..\inc\config; ..\tools
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openeit.hex
  ILINK.IlinkOutputFile: openeit.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; ADI_SYSTEM_CLOCK_TRANSITION
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: ImpedanceMeasurement_4Wire.hex
  ILINK.IlinkOutputFile: ImpedanceMeasurement_2Wire.out
  group (top)
    ../: Readme.txt
  group Driver Sources
    ../src/: afe.c afe_lib.c dma.c gpio.c uart.c wdt.c
  group System Sources
    ../src/: startup.c system.c
  group Test Sources
    ../: lookup.h modes.h OpenEIT.c PinMux.c sequences.h test_common.c
    ../src/: rtc.c
    ../inc/: rtc.h
